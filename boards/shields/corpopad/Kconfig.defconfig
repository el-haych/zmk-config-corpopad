## boards/shields/corpopad/Kconfig.defconfig
```kconfig
if SHIELD_CORPOPAD
# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Corpo Pad"

endif
```
